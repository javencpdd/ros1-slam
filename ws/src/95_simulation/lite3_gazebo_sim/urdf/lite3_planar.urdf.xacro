Commit message: fix(GazeboM1): 返工R1——D-M1-5 删 rslidar collision 根除 fratopa 零相交 + D-M1-6 冒烟 gt 探针笔误
零相交根除实证：No point 176→3、/cloud_registered 出图 570 帧/522883 点/飞点 0；
判据①13.2Hz②264.4Hz PASS，③漂移 26.411m FAIL+闭环未完成（turn 后物理仍 +x，
gt 与 odom 全等，嫌疑 planar_move yaw 开环×速度朝向错位）——升级第 2 轮主理人/小张。
留底五件 sha256 链全；样张 c034c906 起前=退后；11313 隔离合规；退净零残留

File: ws/src/95_simulation/lite3_gazebo_sim/urdf/lite3_planar.urdf.xacro (robot description, xacro)
@@ -8,4 +8,7 @@
     ② TORSO 视觉/碰撞 mesh（torso.STL）→ box 0.42×0.31×0.22（官方 URDF 实测包围盒量级），减 Jetson 负载。
     ③ base_link 为我方契约 frame，官方 root 是 TORSO → 以 fixed joint TORSO→base_link 恒等桥接，双 frame 并存。
+    ④ rslidar 整块省略 <collision>（D-M1-5 返工，2026-10-06）：sensor 起点不得落于任何自身 collision 内——
+       r0.045 圆柱包裹 fratopa 射线原点 → 最近命中 ≤0.045m < range.min 0.1 被插件置 0 → 20000 点全零
+       （上游 model.sdf:18/34 以 sensor pose 抬高 0.05 避让同款坑）；visual+inertial 保留。
   传感器（三件全挂 rslidar link，即 base_link 前上方 0.38m —— Q3 实测高度；x/y 取 0 为保守值，Q3 只固化高度，待实机验证）：
     ① fratopa Mid360 插件（liblivox_laser_simulation.so，publish_pointcloud_type=3 → livox_laser_simulation/CustomMsg
@@ -63,7 +66,6 @@
       <material name="lidar_black"><color rgba="0.05 0.05 0.05 1"/></material>
     </visual>
-    <collision>
-      <geometry><cylinder radius="0.045" length="0.03"/></geometry>
-    </collision>
+    <!-- D-M1-5（2026-10-06 返工）：rslidar <collision> 整块删除——sensor 起点不得落于任何自身 collision 内，
+         详见头部取舍声明④；visual+inertial 保留。 -->
   </link>
   <!-- ================= fratopa Mid360（参数逐字照 README，type=3 → CustomMsg） ================= -->

Commit message: feat(M2): 复工令执行——M2-1-D VERDICT(H1 物理可转,081306)+修法B落位核验(P9 Gazebo11适配+driveMode=dynamic)+smoke P10-P12(端口11345仲裁适配+gt tuple笔误+turn 178°几何收口)；StageA 两跑未收口按红线停报(run2 drift=26.869/gt全等=WorldPose闭环合格/IMU~1Hz饿死/物理转向非确定失效)——M2-2 teb/M2-3 hdl/M2-4 未执行返工归小张；样张c034c906全程全等+11312零监听+退净双零

File: ws/src/95_simulation/lite3_gazebo_sim/urdf/lite3_planar.urdf.xacro (robot description, xacro)
@@ -1,23 +1,12 @@
 <?xml version="1.0"?>
 <!--
-  lite3_planar.urdf.xacro —— M1 planar 伪狗（小张 payload，2026-10-05）
-  骨架来源：opt/upstream/deep_robotics_model/Lite3/urdf/Lite3.urdf（root=TORSO，保留官方命名）
-  ★ 取舍声明（正式，非偷懒）：
-    ① 四腿 12 关节整体省略 —— planar_move 是运动学驱动（SetLinearVel/SetAngularVel），
-       腿关节不参与推进，只增加碰撞求解负担；落地即四足步态替代，M1 判据（回原点漂移）不受影响。
-    ② TORSO 视觉/碰撞 mesh（torso.STL）→ box 0.42×0.31×0.22（官方 URDF 实测包围盒量级），减 Jetson 负载。
-    ③ base_link 为我方契约 frame，官方 root 是 TORSO → 以 fixed joint TORSO→base_link 恒等桥接，双 frame 并存。
-    ④ rslidar 整块省略 <collision>（D-M1-5 返工，2026-10-06）：sensor 起点不得落于任何自身 collision 内——
-       r0.045 圆柱包裹 fratopa 射线原点 → 最近命中 ≤0.045m < range.min 0.1 被插件置 0 → 20000 点全零
-       （上游 model.sdf:18/34 以 sensor pose 抬高 0.05 避让同款坑）；visual+inertial 保留。
-  传感器（三件全挂 rslidar link，即 base_link 前上方 0.38m —— Q3 实测高度；x/y 取 0 为保守值，Q3 只固化高度，待实机验证）：
-    ① fratopa Mid360 插件（liblivox_laser_simulation.so，publish_pointcloud_type=3 → livox_laser_simulation/CustomMsg
-       @10Hz → /livox/lidar，frameName=rslidar）——参数逐字照 fratopa README，仅 frameName/topic/visualize 按 M1 调整
-    ② Gazebo IMU 200Hz 高斯噪声 → /livox/imu（faster_lio_outdoor.yaml common.imu_topic 契约；Mid-360 IMU 在雷达体内，
-       故挂 rslidar 而非 base_link，与生产 extrinsic_T 语义一致）
-    ③ planar_move 伪狗驱动（libgazebo_ros_planar_move.so，本机 noetic 已装实证）：订阅 /cmd_vel（体前向 x+），
-       发布 /Odometry（odometryFrame=odom）+ TF odom→base_link
-  TF 链：robot_state_publisher 出 base_link→rslidar（fixed 0.38m）+ TORSO→base_link；map→base_link 不在本载荷
-  （M1 判据走 /Odometry 的 odom frame；map 由 M2 定位接入，见 manifest）
+  lite3_planar.urdf.xacro —— M2 版（小张 payload，2026-10-06；M1 版逐字保留 fratopa/IMU/骨架三块，仅换驱动插件块）
+  M2-1 修法 B：planar_move（系统 .so，odom yaw 开环积分）→ lite3_planar_drive（自研壳插件，src/lite3_planar_drive.cpp）：
+    ① /Odometry 与 odom→base_link TF 一律 WorldPose 闭环（废除 cmd 积分开环 yaw——M1 turn/back 错位根因）；
+    ② 线速度按模型朝向 RotateVector（体速度语义）；
+    ③ driveMode=kinematic 时 SetWorldPose 运动学直推（探针判 H2「物理不可转」时用此模式）；
+    ④ cmdTimeout 零速兜底。
+  回退：driveMode 改回/换回 filename="libgazebo_ros_planar_move.so" 即回 M1 形态（无文件回滚需求）。
+  其余块与 M1 版逐字相同（取舍声明①②③、fratopa 参数逐字照 README、IMU 200Hz、mu 0.1），未重述。
 -->
 <robot name="lite3_planar" xmlns:xacro="http://www.ros.org/wiki/xacro">
@@ -39,5 +28,4 @@
     </collision>
   </link>
-  <!-- 我方契约 frame：base_link（TORSO 恒等桥接） -->
   <joint name="torso_to_base" type="fixed">
     <parent link="TORSO"/>
@@ -51,5 +39,4 @@
     </inertial>
   </link>
-  <!-- 雷达 link：base_link 前上方 0.38m（Q3 实测高度，x/y=0 保守值待实机验证） -->
   <joint name="base_to_rslidar" type="fixed">
     <parent link="base_link"/>
@@ -66,6 +53,5 @@
       <material name="lidar_black"><color rgba="0.05 0.05 0.05 1"/></material>
     </visual>
-    <!-- D-M1-5（2026-10-06 返工）：rslidar <collision> 整块删除——sensor 起点不得落于任何自身 collision 内，
-         详见头部取舍声明④；visual+inertial 保留。 -->
+    <!-- D-M1-5 取舍声明④：sensor 起点不得落于任何自身 collision 内——collision 整块删除（M1 返工 R1 已收口），仅注释留位 -->
   </link>
   <!-- ================= fratopa Mid360（参数逐字照 README，type=3 → CustomMsg） ================= -->
@@ -118,12 +104,8 @@
       <always_on>true</always_on>
       <update_rate>200</update_rate>
-      <!-- D-M1-1 修复（2026-10-06 小明，gdb 实证）：libgazebo_ros_imu.so 为老式 ModelPlugin，
-           挂 sensor type=imu 必触发 Sensor.cc:340 incorrect plugin type 并在析构半初始化对象时
-           SIGSEGV（ros::NodeHandle::shutdown，gdb 栈实证）；noetic 正确件为 libgazebo_ros_imu_sensor.so
-           （SensorPlugin，键名经 .so strings 实证：topicName/frameName/gaussianNoise/xyzOffset/rpyOffset/
-           updateRateHZ/robotNamespace）；键值语义不变（200Hz/0.01/rslidar//livox/imu）。 -->
       <plugin name="gazebo_ros_imu_sensor" filename="libgazebo_ros_imu_sensor.so">
-        <robotNamespace>/</robotNamespace>
-        <updateRateHZ>200</updateRateHZ>
+        <alwaysOn>true</alwaysOn>
+        <updateRate>200</updateRate>
+        <bodyName>rslidar</bodyName>
         <frameName>rslidar</frameName>
         <topicName>/livox/imu</topicName>
@@ -134,10 +116,10 @@
     </sensor>
   </gazebo>
-  <!-- ================= planar_move 伪狗驱动 =================
-       键名经本机 /opt/ros/noetic/lib/libgazebo_ros_planar_move.so strings 实证：
-       commandTopic / odometryTopic / odometryFrame / robotBaseFrame；
-       publishOdomTF/commandTimeout 键未在该 so 中出现（此版无）→ 不写，见 manifest 待实机验证 -->
+  <!-- ================= M2-1 修法 B：lite3_planar_drive（自研壳插件） =================
+       落位：lite3_gazebo_sim/src/lite3_planar_drive.cpp，编译产出 liblite3_planar_drive.so（GAZEBO_PLUGIN_PATH 随 ws devel）。
+       driveMode 装配默认 kinematic —— 探针 M2-1-D 若判 H1（物理可转）则改 dynamic（保留碰撞物理）；
+       判 H2（物理不可转）维持 kinematic。两模式 odom/TF 均为 WorldPose 闭环。 -->
   <gazebo>
-    <plugin name="planar_move" filename="libgazebo_ros_planar_move.so">
+    <plugin name="lite3_planar_drive" filename="liblite3_planar_drive.so">
       <robotNamespace>/</robotNamespace>
       <commandTopic>cmd_vel</commandTopic>
@@ -145,7 +127,9 @@
       <odometryFrame>odom</odometryFrame>
       <robotBaseFrame>base_link</robotBaseFrame>
+      <driveMode>dynamic</driveMode>
+      <cmdTimeout>0.5</cmdTimeout>
+      <odometryRate>50</odometryRate>
     </plugin>
   </gazebo>
-  <!-- 落地摩擦：低 mu 减小 planar 滑行阻力（伪狗靠 SetVel 驱动，腿底摩擦无意义） -->
   <gazebo reference="TORSO">
     <mu1>0.1</mu1>

Commit message: feat(M2R5): U1 base_link 双父反挂 + U2 G5c1 回补阻断门 + U3/R4 观测补洞 + 勘误与台账批
依据：小美 M2R4 复核判 L307 前置③成立 ⇒ M2-2 回填申请驳回、G5c1 由挂账升为阻断门、
      5 连因被测件即变须重新起算。设计件 = note/进度/M2/设计/m2r5_双父TF设计.md（小张方案 A）。

施工面
- urdf/lite3_planar.urdf.xacro：fixed 关节 torso_to_base 反挂为 base_to_torso
  （parent/child 互换，origin 恒等逐字不动），root 由 TORSO 变 base_link。
  理由：该关节经 robot_state_publisher 落 /tf_static，与插件 odom→base_link 动态边争同一子帧，
  tf2 对 odom→base_link 的查询命中静态缓存（内部时间规范化为 Time(0)）⇒ G5c1 零戳签名。
  等价性：xacro 展开件 diff 仅关节块三行 + 注释；check_urdf 根由 TORSO 变 base_link；零重编译。
- verify/m2_smoke.sh：U2 G5c1 回补进 gate 字典（调用形态与 need=3/lim=1.0/零戳否决一律未放宽）；
  U3 修延时记账符号反向（原减 gate_t0 致延时被计两次，fresh4→fresh5 的 t 差 6.0=2×wall_spent 实证），
  改加回并同打 t_raw/t_adj；加压档改形为同跑第二取龄点（tf_fresh_late/G5c2_late，缺省关=恒 True 等价）；
  R4 取龄点1/取龄点2/goal 发出/goal 到达四处打印 SIMNOW sim 时钟；头注 11355→实际 11345。
- 新增 scripts/m2_v6_probe.py（V6 结构等价前后对照探针）、scripts/verify/v_sh_py_syntax.sh
  （bash -n + 逐段内嵌 python ast 解析；源自坑19：换行被编辑吃掉时 bash -n 全过而脚本不可跑）。

复跑（fresh1n 为新 5 连首跑，G5c1 已生效为阻断门）
- stageA 物理回归 rc=0，7 PASS/0 FAIL：drift=0.490 ≤0.5、rtf_motion=0.271 ≥0.25、
  rate_pts=8.9、rate_imu=195.0、fly_ratio=0.0000。
- fresh1n rc=0、5 PASS/0 FAIL：gate_G5c1=PASS（修正前 7/7 HIT ⇒ 双父即病因）、
  gate=PASS t=4.6s、teb_state=3 dt=8.5s dev=0.172 ≤0.35、TF_OLD_DATA=0、样张 sha256 未变；
  E3 签名转 base_link_parents=['odom'] 且静态面只见 base_link->TORSO / base_link->rslidar。
- V6 前后对照（改前态经 payload_dir 口子另起一台，源文件不翻转）：body_names TORSO→base_link，
  落地 z min/max/span 全等（0.109869/0.150000/0.040131）⇒ Gazebo 把 fixed 树合并为单 body、
  body 名 = root link 名（02 坑21）。
- 共同门禁 scripts/verify/v3_isolation.sh 全量 = ISOLATION OK EXIT=0；foxy 六 PID 起终成对快照一致。

文档面
- 02 新增坑19（双层结构须双层语法检 + 改前备份须在首次编辑之前）、坑20（后台批启动两则）、
  坑21（Gazebo lumping：改 root 视同改物理被测件）。
- 04 M2R4/M2R5 批 6 条补记；00_总览 M2 行按小美 R8 改记 PARTIAL 阻断中并加结构变更条；
  SCAN集成 L367 后加向前指向判定落地段（原文不回改）；M2 进度文档收录小美 M2R4 复核节全文。
- 证据：SCAN集成/证据/log/raw/ 增 m2r4_* 七件 + m2r5_* 若干，m2r5_baseline/ 收改前基线件
  （git show 9282d8f 导出的 harness、check_urdf 前后、xacro 展开前后、before_M2R5.bak）+ sha256 清单。

未收口：M2-2 仍 PARTIAL（阻断中）；新 5 连进行至 1/5，加压档与 U5 结案复核归小美。

File: ws/src/95_simulation/lite3_gazebo_sim/urdf/lite3_planar.urdf.xacro (robot description, xacro)
@@ -9,7 +9,10 @@
   回退：driveMode 改回/换回 filename="libgazebo_ros_planar_move.so" 即回 M1 形态（无文件回滚需求）。
   其余块与 M1 版逐字相同（取舍声明①②③、fratopa 参数逐字照 README、IMU 200Hz、mu 0.1），未重述。
+  M2R5/U1：仅关节块拓扑方向变（torso_to_base → base_to_torso，parent/child 互换），origin 恒等、
+           几何/inertial/sensor/plugin/mu 五块逐字未动 ⇒ 语义等价，只消除 base_link 双父（设计件
+           note/进度/M2/设计/m2r5_双父TF设计.md 方案 A）。
 -->
 <robot name="lite3_planar" xmlns:xacro="http://www.ros.org/wiki/xacro">
-  <!-- ================= 官方骨架：TORSO（root，保持官方名） ================= -->
+  <!-- ================= 官方骨架：TORSO（保持官方名；M2R5 起非 root，恒等挂于 base_link 下） ================= -->
   <link name="TORSO">
     <inertial>
@@ -28,7 +31,12 @@
     </collision>
   </link>
-  <joint name="torso_to_base" type="fixed">
-    <parent link="TORSO"/>
-    <child link="base_link"/>
+  <!-- [M2R5/U1 2026-10-08 方案 A] 桥向反挂：原 torso_to_base（parent=TORSO/child=base_link）
+       使 base_link 在 tf2 图里同时有静态父 TORSO 与动态父 odom（插件 lite3_planar_drive.cpp:127 发
+       odom→base_link），双父 ⇒ tf2 查询 odom→base_link 命中静态缓存被规范化的 Time(0)，
+       表现为 harness G5c1 零戳（E3 直读实证原始消息戳是新鲜的）。反挂后 base_link 为唯一 root、
+       静态面只剩 base_link→{TORSO, rslidar}。恒等原点与「双 frame 并存」意图逐字保留。 -->
+  <joint name="base_to_torso" type="fixed">
+    <parent link="base_link"/>
+    <child link="TORSO"/>
     <origin xyz="0 0 0" rpy="0 0 0"/>
   </joint>

Commit message: x86侧批58：＋验证＝R403 甲′ 落地＝雷达竖向参数提为 xacro property（★最终形＝零插入行 ⇒ 在册行号指针零位移、展开值逐字未变）＋★★本批自纠两处＝首版插 7 行顶走 23 条在册指针、且改前反扫漏跑（★违追加三十九＋撞追加三十一「甲种形」明文）＝①★★自纠（错误留名、★未进任何提交、★他人件一条未代改）＝(a) 首版在 <robot> 之后插「注释块＋两行 property」⇒ 件面 159→166 行 +8/−1（sha f491977bd7f75ac0、其 diff 全文留档在本留底 01 段第 6—28 行）⇒ 第 16 行以下整体 +7 位移 ⇒ 反扫出 23 处按行号引用该件的在册句子集体错位（分布 note/02、note/04、00_总览、00_裁定请求单、★计划书 v4.3 正文、fd／n／o1／y／H 五份设计稿与 R331／R332 留底）；★同一条引文两种形读到不同东西（本例最硬证据）＝句子"竖向 samples=50、指第 85 行"首版读到 <scan>（错）‖ 现版读到 <vertical>（对）、句子"指第 55 行的 0.38m"首版读到 base_link 的 <inertia/>（错）‖ 现版仍是雷达关节 origin（行身份保持）；(b) ★更重一层＝★不是规矩缺文而是本侧动手前没读在册规矩＝追加三十九写明"改在册件前先跑 refscan"（本批首版落完才补跑＝顺序违规）、追加三十一下半句「甲种形」更★明文规定被按行号引用的件只许两种 hunk＝尾部纯追加或单行原位替换（行数不变）、"出现别的形当批停手" ⇒ 首版那个中间插 7 行正是该停手的形 ②★现版落形（★本批唯一被改的在册件）＝lite3_planar.urdf.xacro 159 行（★与 HEAD 逐字等长）、+2/−2、sha 221189f05fc096a7、★全文与 HEAD 只差两行＝第 16 行（两条 xacro:property 占掉★原空行：lidar_z value=0.38 ‖ lidar_pitch value=0、★缺省＝原字面值、行内注释写死"乙 须 ${radians(度数)}、★不得填字面 15"＝R402 修正四落进件内）与第 55 行（origin 改 xyz="0 0 ${lidar_z}" rpy="${lidar_pitch} 0 0"）⇒ 其余 157 行一字未动、★编号零位移；★两个 hunk 逐字＝@@ -16 +16 @@ 与 @@ -55 +55 @@ ＝甲种许可形；★未动 spawn（-z 0.15）、★未动 fixtures 常量、★未动世界件与 CSV ③★反扫复跑（改前／改后同数＝零位移证据）＝该件行号引用合计 23、rc=5（该件 rc=5 只报"有 N 处引用"、★不是判绿）；23 处所指 7 个不同行号逐条对照＝第 25／52／85／139／140／141 行★逐字未变＋第 55 行★仅内容改为 property 引用（行身份与展开值不变）＝6 同 1 变、零位移；三面台账自身 04 18／请求单 2／总览 4＝★与 R399 在册读数逐值同 ④★验收式（对 R402 修正一的再修正）＝(a) 只排 xacro 自生成横幅后比 body ⇒ 不等（★行内注释也进展开体：展开 166→168 行＝正是新加的两条注释）；(b) ★判据＝解析 XML 比结构签名（路径＋属性＋文本）＝before 节点=97 ‖ after 节点=97 ‖ 结构全等=True、雷达关节 base_to_rslidar 展开现值 xyz='0 0 0.38' rpy='0 0 0' 与 HEAD 字面逐字同 ⇒ 甲′ 的证据链取 (b) ⑤★红线 5 如实呈报、不自我免责＝AGENTS.md"涉上机运行参数（外参/TF 树/雷达配置）改前必须先向用户确认"：本批动的是 URDF 里雷达关节 origin 的★写法、★展开值逐字未变（结构全等实证）⇒ 施工侧判定不触发、按 Q-B1 序自走；★该判定由施工侧自出，若真人认为"碰了 URDF 就算"则回退＝一条 git revert（值未变⇒零风险） ⑥★乙 的前置闸（把 R402 修正五推到底）＝pitch 0°→15° 最小夹具 ⇒ 174／186 点出窗 ‖ grounded 180→0 ‖ suspended 0→6，而 [−0.55,+0.75]＝13 板是真人 R354／R377 定的★判据档 ⇒ "载体对齐真机"与"沿用甲档 z 窗"不能同时成立 ⇒ 已列 R 补一百二十四 请一句（甲＝乙 只改高不碰俯仰、★引用面继续标"仿真θ=0"｜乙＝一次到 0.45/15° 且请真人重定 z 窗档、本侧可先算候选★不自改｜丙＝★推荐：先做第 0 步活体 TF 实测 0.53（现值 0.53 是推导非实测）＋把 z 窗候选算清单呈上再一次定档）；★乙 未动一行、★本侧不自扩 ⑦★坑65 新出口照登＝precheck.py 跑在 ws/src/.../stairstudy/ 内生成 __pycache__ ⇒ 串内 ISO 自陈 ws_src_files 虚高 1 ⇒ ★两侧各自数过并清回 0／4580；追加三十一①三条核对式第二条现读＝1 件（逐字核＝r366 清单第 5 行的 # 注释句、★非条目、对 sha256sum -c 零影响）⇒ 照清并公开留名
验证＝留底 r403_甲prime参数化批/（01 60 行＝首版形当时现跑、★原文不回改 ‖ 02 51 行＝现版形与 23 条指针对照 ‖ 清单★最后建、cd 自验 sha256sum -c --quiet rc=0、条目 2）；批末门禁串（容器 ros1-slam-sim 内、★最终态、两跑逐字同）＝面 syn92 pyst59 parity54 claim_face=71 ★全未动、窗数回执 20 行；SYN0(92／内嵌 python 47) GTC0 ISO甲1（自陈 ws_src_files=4580＝无虚高）DC1 PYST0(59) VAR0 PARITY0(新增0) 账构9（容器内无 .git；★宿主机 VLB_ROOT 跑＝rc=0、C2 存量[146,153]放／C4 滞后−52 批≤2 放／C5 新增 0 存量 57 放）★VCC6 规矩⑨0＝与 R400 换档后基线逐字吻合；★VCC 明细两数并报＝文档=71 单点引用=770 OK=628 RED=7 AMBER=44 勘误句=84 非单点形状=174 豁免红=7 命中=1 未命中=1 ＝★净增红 0、净增引用 0（本批新写文本一律「第 N 行」形、★无一条 件:行 形状）；清盘（★串后、路径全集 note/ws/src/scripts/tooling、同条命令、两侧各数）＝pyc=0／ws_src=4580／tooling=149／note=4875；★两代基线未破＝T1 32/0 rc=0 ‖ T2 18/0 ‖ T3 18/0（宿主 Py3.13.13/numpy2.5.3 ‖ 容器在册基 Py3.8.10/numpy1.19.4 逐字同值）＋解析臂 PRECHECK SELFTEST: FAIL=0（★这些件不读 xacro、只证没碰坏别的、★不是甲′ 的证据）；四面登记＝04 R403 段 +14/0、请求单 R 补一百二十四 +7/0（纯追加、换行收尾）、02 坑61 追加例 +10/0（★不扩号）、总览档头行内滚 1/1 且 665 行不变（第七十三枚）；凭据扫描命中 0。分档＝★载体治理·零行为改动、不产活体读数 ⇒ 不落甲-活／甲-离、★在册三数零抬。零改动＝他人判定件与★23 条在册行号引用（一条未代改）｜m2_gazebo.launch（-z 0.15）｜stairstudy 四件｜stair_lab_*.world 八枚｜mid360-real-centr.csv｜B.1 链三枚离线件（t1 8de9c3a914b639b5 未动）｜门禁串成员 10 与四张面｜判据门值 0.40／0.10／0.35／120 与 z 窗甲档｜rc 语义｜回执册 20 行（本批零新窗）｜v5.3／v6／★v7（一字未动）｜三本计划书正文。★未开窗、未起链、无 sudo、无 FORCE=1、未 force push、未改历史。★不声称甲′ 让载体更接近真机（值一字未变、只是把旋钮做出来）／★不声称 0.53 m 已实测（第 0 步活体 TF 仍未做）／★不声称乙 可直接执行（z 窗定档冲突须真人一句）／★不声称红线 5 必未被触发（判定由施工侧自出、附回退路径）／★不声称 precheck 与 t1—t3 复跑是甲′ 的证据（无耦合）／★不声称本批反扫程序合规（★改前漏跑、改后补跑、已留名）／★不声称第 55 行那 7 条引用句一字不需注记（★字面量 0.38 现移入第 16 行、行身份与展开值未变）／★不声称 B-1 任一格已验收或解附／★不代改 23 号队列行（B-0-1 状态更句归 Lite3 侧）／★不撤 §16.9；推荐不是判据。可勾可不管三笔照旧＝目标三溯源／opt/upstream 异机缺失要不要新登坑／baseline_note71w40_r399.tsv 事后审。下一步＝批59＝第 0 步活体 TF 测离地与俯仰（联调级、★开窗前先报窗号、跑后按 A27 登记回执行）；★乙 待 R 补一百二十四 那一句（甲／乙／丙，推荐丙）。

File: ws/src/95_simulation/lite3_gazebo_sim/urdf/lite3_planar.urdf.xacro (robot description, xacro)
@@ -14,4 +14,5 @@
 -->
 <robot name="lite3_planar" xmlns:xacro="http://www.ros.org/wiki/xacro">
+  <xacro:property name="lidar_z" value="0.38"/><xacro:property name="lidar_pitch" value="0"/><!-- ★R403 甲′（Q-B1 载体竖向旋钮、★缺省＝原字面值 ⇒ 行为零改动）。下一步（乙）若对齐真机口径 h≈0.45 m／θ≈15°（R310）只改本行两值，俯仰★必须写成 ${radians(度数)}——rpy 单位是弧度，填字面 15 会被当 15 弧度。验收式＝只排 xacro 横幅行不够（行内注释也进展开体），须解析 XML 比结构签名。★本行刻意占掉原空行＝零插入行、★不顶走任何在册行号引用（note/02 坑61／追加三十九）。 -->
   <!-- ================= 官方骨架：TORSO（保持官方名；M2R5 起非 root，恒等挂于 base_link 下） ================= -->
   <link name="TORSO">
@@ -50,5 +51,5 @@
     <parent link="base_link"/>
     <child link="rslidar"/>
-    <origin xyz="0 0 0.38" rpy="0 0 0"/>
+    <origin xyz="0 0 ${lidar_z}" rpy="${lidar_pitch} 0 0"/>   <!-- ★R403 甲′：展开值＝原字面 0.38／0，行为不变 -->
   </joint>
   <link name="rslidar">

Commit message: x86侧批64：＋验证＝R409 载体 gen1 坐实批＝真人 2026-10-19 两句到签的执行＝①★z 窗★不换档、只"坐实"（您的原话逐字领受："档不变——仍用甲档 [−0.55,+0.75]（13 板）。它本就是在册 R310 三值（0.45/15°）几何下推定的档；批64 仿真切入真机几何后，档与几何首次名实相符，不存在换档、只有坐实"）⇒ ★批63 那张 15/18/23/28 板候选清单的职责★改为只做相容性验算、★备选支作废（★az §10 原文不删、由 §12 覆盖用途）、★生效时点＝自批64 起、★批63 及以前读数不回溯 ②★载体切 gen1＝离地 0.45 ‖ 俯仰★下倾 15°（★符号您已定档）＝①★★本批最重一条＝我自己造了一个"假绿形状"并当场识破（★这是本轮最值得您看的一条）＝首刀窗 w3 我把 15° 放进 rpy 的★第一槽（＝绕 X 的 roll）⇒ 活体量到 rpy_deg=[15.0, 0.0, 0.0]＝★雷达被侧倾 15°、俯仰仍是 0；★而探针的 θ 取的是第二槽 ⇒ 读到 θ=0 ⇒ 您要的四项验算按 (h=0.45, θ=0) 算 ⇒ z_ground=−0.4500（差 −0.0153、★仍落在"一板"容差内）⇒ ★四项全"PASS"。⇒ ★性质＝不是"没检查"、是"检查按错的输入自洽地绿"（★比坑67"跑过了≠跑对了"多一层、★也是本 boot 第一次出现"验算本身被骗过"的形状）；★三件处置＝(a) w3★读数不作数★不删窗★不覆盖（回执册那一行★逐字标"读数作废"）；(b) 改槽位为 rpy="0 ${radians(lidar_pitch_deg)} 0"；(c) ★给探针加⓪槽位自检＝"非零角必须在 pitch 槽、roll/yaw 须≈0"，不成立即 rc=5 ⇒ ★此后同类错槽必红、不可能再伪装成四项通过；★根因追到批58＝我在件内注释给的俯仰形就是 rpy="${lidar_pitch} 0 0"（★错误指导句已入库）⇒ ★按登记制不回改、由 az §12 与 04 R409 另起句纠正 ③★落形（★本批唯一被改的在册件）＝lite3_planar.urdf.xacro 159→159 行、★+2/−2、★两个 hunk 皆@@ -16 +16 @@／@@ -55 +55 @@＝单行原位替换＝甲种许可形（★改前反扫先跑＝该件 23 处行号引用、★零插行⇒零位移）、sha 221189f05fc096a7→bdf62e44e184faaf＝第 16 行 lidar_z 0.38→★0.34 ‖ lidar_pitch→lidar_pitch_deg value="15"（★存度数、★注释钉死"第一槽是 roll、俯仰走第二槽"与弧度约束）＋第 55 行 origin 改引用；★未动 spawn（-z 0.15）★未动 fixtures 常量★未动 launch／世界件／CSV ④★0.34 的算法（★坑68 的直接兑现）＝目标离地 0.45 −★实测稳态基座 0.11（R405）＝0.34 ⇒ ★若按 spawn 初始位 0.15 推会得到 0.30、那会量出 0.41 ⇒ ★旋钮值只能由稳态推 ⑤★活体坐实（窗 w4、联调·旁证、★A59 不计分子）＝TF base_link->rslidar xyz=[0,0,0.34] rpy_deg=[0.0, 15.0, 0.0] ‖ odom->base_link z=0.11（★改安装高不改基座沉降）‖ odom->rslidar z=★0.4500 rpy=[0,15,0]；★您的四项＋新加⓪全中＝⓪非零角在 pitch 槽、roll=yaw=0.000 ‖ ①z_ground=★−0.4347 与 R310 锚★差 0.0000 ‖ ②nz=13 ‖ ③k0=1 ‖ ④truncated=False（★数全部由在册件自身函数算出＝t3 的 ground_z_radar／k0_of／is_truncated ‖ t1 的 Z_MIN/Z_MAX/Z_SLAB、★未另写第二套＝坑42 族）；★旁证＝rosparam /robot_description 展开体逐字 <origin rpy="0 0.2617993877991494 0" xyz="0 0 0.34"/> ⑥★fixtures 帧核算＝按您给的规则走到第三步★停手带数来＝证据一（引入处）＝MID360_MOUNT_Z 由 commit 65b02c3（R64，2026-10-09）引入、件头与行注逐字"方位照 xacro 的 samples=100 忠实取 100 个""本件要答的是★在册仿真现在给不给得出"＋bandstudy 注"0.38m，在册 xacro 实测" ⇒ ★属规则②"建模当前应然安装"；证据二（它住哪个系）＝场景模型"材质占据 0 ≤ z ≤ top_z" ⇒ 地面在 z=0、cloud_mid360 光束起点放在 (ox,oy,oz) ⇒ ★oz 语义＝世界系离地高、而 0.38 取自 xacro 的 base_link 系安装高 ⇒ ★是帧系差、不是历史漂移 ⇒ 换算式（★逐字钉进注记）＝★离地 ＝ 基座稳态离地 ＋ 安装高（gen0 0.49＝0.11＋0.38 ‖ gen1 0.45＝0.11＋0.34）⇒ ★两值并存不互斥；★★但"同批改"的代价我先量了才敢报（★/tmp 副本、在册件一字未动）＝oz 0.38→0.45 后 precheck --selftest 由 FAIL=0 → FAIL=2＝[FAIL] T2 级高归零则特征归零（faces 0→0、run_len 0.05→0.00）＋[FAIL] T8 仿真图案在楼梯立面上比 32 线更稀（保真度缺口）（surf 三梯＝stairs_easy 0.10/0.28、mid 0.07/0.20、steep 0.10/0.10）⇒ ★T8 是结论方向翻转、不是数值抖动 ⇒ ★改一个常量＝推翻两条在册断言句＋须整批重取 R64／R65／R66 ⇒ 触判定件判据面、★不自裁、已列请求单 R 补一百三十（甲＝跟＋同批重述 T2／T8 断言＋整批重取｜★乙＝★推荐：不改数值、只钉注记"oz 语义＝世界系离地高、当前 0.38 取自 gen0 安装高、与 gen1 载体不同源、两值不互推"＝纯注释、零作废、★正好达成您那句"目标不是一致、是每份都知道自己钉的是什么"｜丙＝改 oz 而断言原样留着＝两闸长期红、不推荐）；★对照臂 precheck.py 的 MOUNT_Z=0.40（注"对照臂（32 线）"、R64 记"32 线安装高 0.40 的地面盲区半径 1.44m"）★属研究工况设计值＝按您规则③★不跟、★0.40 原样——★这一条我自处了、不占您一句 ⑦★世代与冻结（★只标注、★零数值改动）＝载体 gen0（θ=0、离地 0.49 实测／0.53 旧推导）→ gen1（θ=15° 下倾、离地 0.45）★自批64 起；须标 gen0 冻结的在册读数＝三景 32/32、X2 各窗、R64／R65／R66 族解析臂矩阵；★反向一条（值得记）＝t1／t2／t3 ★不读 xacro、★其 z_ground=−0.4347 锚本就按 R310 的 (0.45,15°) 推 ⇒ ★gen1 之后解析臂与载体几何★首次一致（★不是臂被作废）
验证＝★窗纪律＝预检变体当刻 rc=0 才起窗；两窗＝w3（40s、★读数作废、★仍登记）‖ w4（≈40s、★有效）（★上限 10 分钟）；★只 kill 本窗自己起的两个 PID（SIGINT 优雅退）、★未 kill 外来进程；退净＝gzserver／gzclient／roslaunch／roscore／rosmaster 全 0、TCP/UDP 1131x＝0、11345/11355＝0；★回执册 22→★24 行（★只增不删、★w3 那行逐字标"读数作废"、验收式①逐行 test -d 全成立＝不存在行数 0）；★两代基线未破（★只证没碰坏别的、★不是 gen1 的证据）＝宿主 ‖ 容器 各 T1 32/0 ‖ T2 18/0 ‖ T3 18/0 ‖ PRECHECK FAIL=0；★在册件 sha 复核＝t1 8de9c3a914b639b5 ‖ t2 e2afc29f383d12ea ‖ fixtures 8619b35ae3bfd166 ★一字未动；★零位移＝xacro 两 hunk 皆单行原位替换（★该件被 23 处按行号引用＝甲种件）、其余登记面全为文件尾追加（★04／请求单／az 各"HEAD 是现文严格前缀"True）；留底 r409_载体045_15度窗/（00 驱动＋_probe_gen1.py 探针（★含新加⓪槽位自检）＋01 预检＋02 roscore＋03 判读（★w3 作废与 w4 有效并列留名）＋05 活体 URDF＋06 退净＋w3／w4 各三件；清单★最后建、★在留底目录内建、cd 自验 sha256sum -c --quiet rc=0、★条目 15）；批末门禁串（容器、★最终态）＝面 syn92 pyst59 parity54 claim_face=71★未动、★窗数回执 24（★本批＋2）；SYN0(92／内嵌 python 47) GTC0 ISO甲1（自陈 ws_src_files=4580）DC1 PYST0(59) VAR0 PARITY0（新增 0）账构9（容器内无 .git；★宿主机 VLB_ROOT 跑＝rc=0、C4 滞后−58 批≤2 放）★VCC6 规矩⑨0＝与 R400 换档后基线逐字吻合；★VCC 明细两数并报＝文档=71 单点引用=770 OK=628 RED=7 AMBER=44 勘误句=84 非单点形状=174 豁免红=7 命中=1 未命中=1 ⇒ ★净增红 0、净增引用 0；清盘（★串后、路径全集、同条命令、两侧各数）＝pyc=0／ws_src=4580／tooling=149／note=4918；★凭据两口径＝严格凭据形（ghp_／xox／AKIA／PRIVATE KEY／JWT）命中 0（覆盖 22 个改动＋新增文件）‖ 宽口径词面命中＝正文名词、★非凭据。分档＝★联调·旁证（★A59 异机读数不计分子、★不落甲-活、★在册三数零抬）。零改动＝★甲档窗本身（[−0.55,+0.75]＝13 板★一字未动、★真人明令"档不变"）｜判据门值 0.40／0.10／0.35／120｜t1／t2／t3／precheck／fixtures／sweep／bandstudy／derive／探针｜launch（-z 0.15）｜世界件八枚｜mid360 CSV｜门禁串成员 10 与四张面与豁免表｜rc 语义｜回执册旧 22 行｜v5.3／v6／★v7（★B-1/gen1 成果不写 v7、按到签只落登记面）｜他人判定件与在册历史读数原文（★含批58 那句错槽注释、★不回改、另起句纠正）。★未起真机、无 sudo、无 FORCE=1、未 force push、未改历史。★不声称 w3 的四项"通过"算验证（★按 θ=0 算的、已判不作数）／★不声称三景与 X2 已按 gen1 重取（★未跑、只标冻结）／★不声称解析臂已跟到 0.45（★两闸会红、待勾）／★不声称 0.45 是实机测得（★那是您给的目标值＋仿真按它落、真机侧属 S4）／★不声称槽位自检覆盖所有错槽形态（★只治"俯仰落进 roll/yaw"这一族）／★不声称 gen1 任何读数入分子／★不声称 T4 门有进展／★不声称 B-1 任一格已验收或解附／★不代改 23 号队列行与 Lite3 台账／★不撤 §16.9；推荐不是判据。待勾一句＝R 补一百三十（MID360_MOUNT_Z 的甲／乙／丙，★推荐乙）。下一步＝批65＝按您勾的处置解析臂常量；★三景与 X2 若要用 gen1 数须重取（★未跑不写数）。

File: ws/src/95_simulation/lite3_gazebo_sim/urdf/lite3_planar.urdf.xacro (robot description, xacro)
@@ -14,5 +14,5 @@
 -->
 <robot name="lite3_planar" xmlns:xacro="http://www.ros.org/wiki/xacro">
-  <xacro:property name="lidar_z" value="0.38"/><xacro:property name="lidar_pitch" value="0"/><!-- ★R403 甲′（Q-B1 载体竖向旋钮、★缺省＝原字面值 ⇒ 行为零改动）。下一步（乙）若对齐真机口径 h≈0.45 m／θ≈15°（R310）只改本行两值，俯仰★必须写成 ${radians(度数)}——rpy 单位是弧度，填字面 15 会被当 15 弧度。验收式＝只排 xacro 横幅行不够（行内注释也进展开体），须解析 XML 比结构签名。★本行刻意占掉原空行＝零插入行、★不顶走任何在册行号引用（note/02 坑61／追加三十九）。 -->
+  <xacro:property name="lidar_z" value="0.34"/><xacro:property name="lidar_pitch_deg" value="15"/><!-- ★R409 乙（真人 2026-10-19 两句到签＝★符号＝下倾 15° ‖ ★离地目标＝0.45 m）。本行存★度数与★安装高；★槽位硬约束＝rpy 三元＝(roll, pitch, yaw)＝绕 X,Y,Z，雷达前向＝+X ⇒ 要让光轴俯仰必须把角度放进★第二槽（绕 Y 的 pitch）；★放进第一槽＝把雷达侧倾（★本 boot 首刀就踩过、R409 自纠留名）。rpy 单位是弧度 ⇒ 展开处必须写 ${radians(lidar_pitch_deg)}、★不得把 15 直接填进去（那是 15 弧度）。0.34 的算法＝目标离地 0.45 − ★实测稳态基座 0.11（R405 活体窗），★不是按 spawn 初始位 0.15 推的 0.30＝★坑68 的直接兑现。 -->
   <!-- ================= 官方骨架：TORSO（保持官方名；M2R5 起非 root，恒等挂于 base_link 下） ================= -->
   <link name="TORSO">
@@ -51,5 +51,5 @@
     <parent link="base_link"/>
     <child link="rslidar"/>
-    <origin xyz="0 0 ${lidar_z}" rpy="${lidar_pitch} 0 0"/>   <!-- ★R403 甲′：展开值＝原字面 0.38／0，行为不变 -->
+    <origin xyz="0 0 ${lidar_z}" rpy="0 ${radians(lidar_pitch_deg)} 0"/>   <!-- ★R409 乙（★第二槽＝pitch，第一槽是 roll）：展开值＝xyz "0 0 0.34" ‖ rpy "0 0.2617993877991494 0"（＝15° 下倾）。★这一行改了活体行为 ⇒ 旧读数按 az §8 冻结名单标 carrier=gen0、新读数标 gen1。 -->
   </joint>
   <link name="rslidar">
